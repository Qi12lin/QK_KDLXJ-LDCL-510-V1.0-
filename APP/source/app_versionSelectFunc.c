/******************************************
* 文    件：versionSelectFunc.c
* 功    能：离心机型号选择
* 说    明：
* 作    者：PZ
*******************************************/


#include "typedef.h"


//拷贝整型数组
void IntArrayCopy(const vu16 *SourInt, vu16 *DesInt, vu8 len)
{
	vu8 i;
	if(SourInt == NULL || DesInt == NULL ) return ;
	DesInt[0] = 0;
	for(i = 1; i <= len; i++)
	{
		DesInt[i] = SourInt[i];
	}
}
//---------------------------------------------------------------------------
const unsigned int max_speed[]={
16600,16600,13000,13000,12000,13000,12000,10000,10000,3000,   //KH19A 10
19560,19560,16810,12280,14480,14740,16740,11260,12290,1170,	
	
6000,5500,4000,4000,4000,4000,4000,4000,4000,4000,4000,   //KL06A 11
5120,5640,3150,3150,3150,2930,2930,3350,2960,2960,2540,	
	
6000,5500,4000,4000,4000,4000,4000,4000,4000,4000,4000,   //TDL5M 11
5120,5640,3150,3150,3150,2930,2930,2960,2960,2960,2540,	
	
16000,13000,12000,13000,13000,11000,14000,11000,10000,10000,10000,12000,13000,12000,15000, //LY_TGL-16M  15
21532,11903,14800,15100,12810,12840,18640,12840,10320,10420,10420,14800,18510,14800,21000,
	
18500,15000,13000,15000,13000,12000,14000,12000,10000,10000,10000,13000,13000,12000,15000,     //TGL18M   15
24637,14800,17940,21000,12810,14800,18640,14800,9690 ,9690 ,10290,18640,18510,14800,21000,

20500,16000,15000,16000,13000,13000,14000,13000,10000,10000,10000,14000,13000,12000,15000,     //TGL20M  15	
29800,17420,23120,23200,12810,17380,18640,17380, 9690,9690, 10290,20595,18510,14800,21000,   
	
6000,4000,4000,4000,4000,4000,4000,4000,4000,4000,      //AJY_A6K   10
6080,3520,2810,2810,2810,2910,3300,3520,3520,2300,


};
const unsigned char max_set1_j[]={0,10,11,11,   15,15,15,13,13,15,  6,1,1,11};   //转子个数

//提取前面所以型号的转子个数
unsigned char get_rotor_N(unsigned char _type)
{
	unsigned char i;
	unsigned int n=0;
	
	for(i=0;i<_type;i++)
	{
		n+=max_set1_j[i];
	}
	return(n);	
}
//-----------------------------------------------------------
//提取选择型号的转子信息
//type--型号
//----------------------------------------------------------
void get_rotor_info(unsigned char type,u16 *speed,u16 *force,unsigned char *rotorkind)
{
	unsigned char i;
	unsigned int n=0;
	
	*rotorkind =max_set1_j[type];
	for(i=0;i<type;i++)
	{
		n+=max_set1_j[i];
	}
	for(i =0;i< max_set1_j[type];i++)
	{
		speed[i+1] =max_speed[2*n+i];
		force[i+1] =max_speed[2*n+(*rotorkind)+i];
	}
	//(*rotorkind)++;
}
//获取型号信号


void GetVersionInfo(void)
{

	
}


   
