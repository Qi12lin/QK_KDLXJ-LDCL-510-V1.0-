# Keil uVision project project.uvprojx, settings and files
target TR100D (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F407VE STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.11.0
  cpu: IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) IROM(0x08000000,0x80000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: TR100D +hex
  AfterMake: D:\keil\ARM\ARMCC\bin\fromelf.exe --bin --output ./Flash/TR100D.bin ./Flash/exe/TR100D.axf
  c flags: Optim=4 oTime=1 v6Lang=1 v6LangP=1
  c define: STM32F40_41xxx,USE_STDPERIPH_DRIVER,USE_USB_OTG_FS
  c include: ..\CORE;..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\USER;..\MALLOC;..\FATFS\exfuns;..\FATFS\src;..\FWLIB\inc;..\USB\USB_APP;..\USB\STM32_USB_OTG_Driver\inc;..\USB\STM32_USB_HOST_Library\Core\inc;..\USB\STM32_USB_HOST_Library\Class\MSC\inc;..\DRIVER\include;..\APP\include;..\MPU6050
  memory RVCT4: ROM 0x8010000 size 0x70000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group USER
    ../USER/: main.c stm32f4xx_it.c system_stm32f4xx.c
  group DRIVER
    ../DRIVER/source/: sdio_sdcard.c spi.c w25qxx.c bsp_24xx02.c bsp_driver.c bsp_i2c_gpio.c bsp_gpio.c bsp_timer.c bsp_uart.c MODBUS_RTU.C UART_VGUS.C bsp_mcp3208.C bsp_adc.c bsp_led.c bsp_button.c rtc.c
  group MPU6050
    ../MPU6050/: kalmen_filte.c kalmen_filte.h mpu6050.c mpu6050.h mpuiic.c mpuiic.h unbalance.c unbalance.h
  group APP
    ../APP/source/: app_ControlComm.c app_comm.c app_start_proc.c app_beep.c app_alarm_record.c app_analog.c app_run_record.c app_versionSelectFunc.c app_user.c app_lock_proc.c app_temp.c app_btn_proc.c app_btn_scan.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/usart/: usart.c
  group CORE
    ../CORE/: startup_stm32f40_41xxx.s
  group FWLIB
    ../FWLIB/src/: misc.c stm32f4xx_dma.c stm32f4xx_fsmc.c stm32f4xx_gpio.c stm32f4xx_rcc.c stm32f4xx_sdio.c stm32f4xx_syscfg.c stm32f4xx_usart.c stm32f4xx_spi.c stm32f4xx_tim.c stm32f4xx_iwdg.c stm32f4xx_adc.c stm32f4xx_rtc.c stm32f4xx_pwr.c
  group MALLOC
    ../MALLOC/: malloc.c
  group FATFS
    ../FATFS/src/: diskio.c ff.c
    ../FATFS/exfuns/: exfuns.c fattester.c mycc936.c
  group USB_OTG
    ../USB/STM32_USB_OTG_Driver/src/: usb_core.c usb_hcd.c usb_hcd_int.c
  group USB_HOST
    ../USB/STM32_USB_HOST_Library/Core/src/: usbh_core.c usbh_hcs.c usbh_ioreq.c usbh_stdreq.c
    ../USB/STM32_USB_HOST_Library/Class/MSC/src/: usbh_msc_bot.c usbh_msc_core.c usbh_msc_scsi.c
  group USB_APP
    ../USB/USB_APP/: usb_bsp.c usbh_usr.c
  group README
    ../: readme.txt
